options:
  parameters:
    author: wangt
    generate_options: qt_gui
    id: sim_gfsk_freqRange
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: '433200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: sensitivity_signal
  states: {}
- name: sensitivity_inf_1
  id: variable
  parameters:
    value: '2.8323'
  states: {}
- name: sensitivity_inf_2
  id: variable
  parameters:
    value: '2.5809'
  states: {}
- name: sensitivity_inf_3
  id: variable
  parameters:
    value: '0.6466'
  states: {}
- name: sensitivity_signal
  id: variable
  parameters:
    value: '1.5756'
  states: {}
- name: signal_bandwidth
  id: variable
  parameters:
    value: '240600'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: tx
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:2236
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:2235
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', zeromq_pub_sink_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_pack_k_bits_bb_0, '0']
- [zeromq_sub_source_0, '0', blocks_char_to_float_0_0, '0']
- [zeromq_sub_source_0, '0', blocks_pack_k_bits_bb_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
