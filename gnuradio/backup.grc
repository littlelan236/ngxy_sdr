options:
  parameters:
    author: wangt
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fc_0
  id: variable
  parameters:
    value: '433200000'
  states: {}
- name: fc_1
  id: variable
  parameters:
    value: '432200000'
  states: {}
- name: fc_2
  id: variable
  parameters:
    value: '432500000'
  states: {}
- name: fc_3
  id: variable
  parameters:
    value: '432800000'
  states: {}
- name: fc_blue
  id: variable
  parameters:
    value: '433920000'
  states: {}
- name: fc_blue_1
  id: variable
  parameters:
    value: '434920000'
  states: {}
- name: fc_blue_2
  id: variable
  parameters:
    value: '434620000'
  states: {}
- name: fc_blue_3
  id: variable
  parameters:
    value: '434320000'
  states: {}
- name: gain
  id: variable
  parameters:
    value: 1 / 1.5
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sensitivity_inf_1
  id: variable
  parameters:
    value: '2.8323'
  states: {}
- name: sensitivity_inf_2
  id: variable
  parameters:
    value: '2.5809'
  states: {}
- name: sensitivity_inf_3
  id: variable
  parameters:
    value: '0.6466'
  states: {}
- name: sensitivity_signal
  id: variable
  parameters:
    value: '1.5756'
  states: {}
- name: signal_bandwidth
  id: variable
  parameters:
    value: '540202'
  states: {}
- name: signal_bandwidth_1
  id: variable
  parameters:
    value: '940466'
  states: {}
- name: signal_bandwidth_2
  id: variable
  parameters:
    value: '860402'
  states: {}
- name: signal_bandwidth_3
  id: variable
  parameters:
    value: '250116'
  states: {}
- name: taps_lpf
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate, 20000, 2000)
  states: {}
- name: taps_lpf_pre
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate, 265000, 2000)
  states: {}
- name: taps_lpf_pre_1
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate, 460774.5453191752, 2000)
  states: {}
- name: taps_lpf_pre_2
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate, 420762.99262587266, 2000)
  states: {}
- name: taps_lpf_pre_3
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate, 115774.37517887364, 2000)
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: gain
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: gain
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\wangt\Desktop\rec\1
    type: complex
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '52'
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(
          gr.sync_block
      ):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name="Hard Decision",  # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32],
              )

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = (input_items[0] > 0).astype(np.int8)
              return len(output_items[0])
    comment: 符号判决
  states: {}
- name: fft_filter_xxx_1_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: taps_lpf
    type: fff
  states: {}
- name: fft_filter_xxx_1_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: taps_lpf_pre
    type: ccc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: signal_bandwidth
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: fc_blue
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.5
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: freq
    nconnections: '2'
    norm_window: 'True'
    type: complex
    wintype: window.WIN_HAMMING
    ymax: '-20'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: raw_iq
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    name: quadrate_and_filtered
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    name: symbols
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:2234
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', fft_filter_xxx_1_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0, '1']
- [analog_quadrature_demod_cf_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_float_to_char_0, '0', blocks_pack_k_bits_bb_0_0_1, '0']
- [blocks_pack_k_bits_bb_0_0_1, '0', zeromq_pub_sink_0_0, '0']
- [blocks_throttle2_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [blocks_throttle2_0, '0', fft_filter_xxx_1_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', epy_block_0_0, '0']
- [epy_block_0_0, '0', blocks_float_to_char_0, '0']
- [epy_block_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [fft_filter_xxx_1_0, '0', digital_symbol_sync_xx_0, '0']
- [fft_filter_xxx_1_0, '0', qtgui_time_sink_x_0_0, '2']
- [fft_filter_xxx_1_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [fft_filter_xxx_1_0_0, '0', qtgui_freq_sink_x_0, '1']
- [iio_pluto_source_0, '0', blocks_file_sink_0, '0']
- [iio_pluto_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
