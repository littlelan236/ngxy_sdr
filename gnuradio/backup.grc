options:
  parameters:
    author: wangt
    generate_options: qt_gui
    id: backup
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: '433200000'
  states: {}
- name: fc_1
  id: variable
  parameters:
    value: '432200000'
  states: {}
- name: fc_2
  id: variable
  parameters:
    value: '432800000'
  states: {}
- name: fc_3
  id: variable
  parameters:
    value: '432500000'
  states: {}
- name: fc_blue
  id: variable
  parameters:
    value: '433920000'
  states: {}
- name: fc_blue_1
  id: variable
  parameters:
    value: '434920000'
  states: {}
- name: fc_blue_2
  id: variable
  parameters:
    value: '434620000'
  states: {}
- name: fc_blue_3
  id: variable
  parameters:
    value: '434320000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sensitivity_inf_1
  id: variable
  parameters:
    value: '2.8323'
  states: {}
- name: sensitivity_inf_2
  id: variable
  parameters:
    value: '2.5809'
  states: {}
- name: sensitivity_inf_3
  id: variable
  parameters:
    value: '0.6466'
  states: {}
- name: sensitivity_signal
  id: variable
  parameters:
    value: '1.5756'
  states: {}
- name: signal_bandwidth
  id: variable
  parameters:
    value: '240600'
  states: {}
- name: taps_lpf
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate, 19230, 2000)
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi)
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi)
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\wangt\Desktop\ngxy_sdr_3\gnuradio\interfere_bitstream
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '52'
    sensitivity: sensitivity_inf_3
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '52'
    sensitivity: sensitivity_signal
  states: {}
- name: digital_gfsk_mod_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '52'
    sensitivity: sensitivity_inf_1
  states: {}
- name: fft_filter_xxx_1
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: taps_lpf
    type: fff
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '50'
    bandwidth: signal_bandwidth
    buffer_size: '32768'
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: fc_blue
    samplerate: samp_rate
    type: fc32
    uri: 192.168.3.1
  states: {}
- name: iio_pluto_sink_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10'
    bandwidth: signal_bandwidth
    buffer_size: '32768'
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: fc_blue_1
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: signal_bandwidth
    bbdc: 'True'
    buffer_size: 32768 * 16
    filter_source: '''Auto'''
    frequency: fc_blue
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.3.2
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    name: rx
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: tx
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    name: raw
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    name: filtered
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:2236
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:2235
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', fft_filter_xxx_1, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_file_source_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_pack_k_bits_bb_0_0_0, '0']
- [blocks_null_source_0, '0', iio_pluto_sink_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', zeromq_pub_sink_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', digital_gfsk_mod_0, '0']
- [blocks_pack_k_bits_bb_0_0_0, '0', digital_gfsk_mod_0_0, '0']
- [digital_gfsk_demod_0, '0', blocks_char_to_float_0, '0']
- [digital_gfsk_demod_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_gfsk_mod_0, '0', iio_pluto_sink_0, '0']
- [digital_gfsk_mod_0_0, '0', blocks_null_sink_0, '0']
- [fft_filter_xxx_1, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [iio_pluto_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [iio_pluto_source_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [iio_pluto_source_0, '0', digital_gfsk_demod_0, '0']
- [zeromq_sub_source_0, '0', blocks_char_to_float_0_0, '0']
- [zeromq_sub_source_0, '0', blocks_pack_k_bits_bb_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
