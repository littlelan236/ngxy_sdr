options:
  parameters:
    author: wangt
    generate_options: qt_gui
    id: sim_gfsk_freqRange
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: '433200000'
  states: {}
- name: fc_1
  id: variable
  parameters:
    value: '432200000'
  states: {}
- name: fc_2
  id: variable
  parameters:
    value: '432500000'
  states: {}
- name: fc_3
  id: variable
  parameters:
    value: '432800000'
  states: {}
- name: fc_blue
  id: variable
  parameters:
    value: '433920000'
  states: {}
- name: fc_blue_1
  id: variable
  parameters:
    value: '434920000'
  states: {}
- name: fc_blue_2
  id: variable
  parameters:
    value: '434620000'
  states: {}
- name: fc_blue_3
  id: variable
  parameters:
    value: '434320000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sensitivity_inf_1
  id: variable
  parameters:
    value: '2.8323'
  states: {}
- name: sensitivity_inf_2
  id: variable
  parameters:
    value: '2.5809'
  states: {}
- name: sensitivity_inf_3
  id: variable
  parameters:
    value: '0.6466'
  states: {}
- name: sensitivity_signal
  id: variable
  parameters:
    value: '1.5756'
  states: {}
- name: signal_bandwidth
  id: variable
  parameters:
    value: '240600'
  states: {}
- name: taps_lpf
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate, 19230, 2000)
  states: {}
- name: taps_lpf_pre
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate, 270000, 10000)
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '52'
    sensitivity: sensitivity_signal
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: signal_bandwidth
    buffer_size: '3276800'
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: fc
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.7
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: fc
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.7
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:2234
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_pack_k_bits_bb_0_0, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_mod_0, '0', iio_pluto_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_sub_source_0, '0', blocks_pack_k_bits_bb_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
