options:
  parameters:
    author: wangt
    generate_options: qt_gui
    id: only_tx_filesource
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: '433200000'
  states: {}
- name: fc_1
  id: variable
  parameters:
    value: '432200000'
  states: {}
- name: fc_2
  id: variable
  parameters:
    value: '432500000'
  states: {}
- name: fc_3
  id: variable
  parameters:
    value: '432800000'
  states: {}
- name: fc_blue
  id: variable
  parameters:
    value: '433920000'
  states: {}
- name: fc_blue_1
  id: variable
  parameters:
    value: '434920000'
  states: {}
- name: fc_blue_2
  id: variable
  parameters:
    value: '434620000'
  states: {}
- name: fc_blue_3
  id: variable
  parameters:
    value: '434320000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sensitivity_inf_1
  id: variable
  parameters:
    value: '2.8323'
  states: {}
- name: sensitivity_inf_2
  id: variable
  parameters:
    value: '2.5809'
  states: {}
- name: sensitivity_inf_3
  id: variable
  parameters:
    value: '0.6466'
  states: {}
- name: sensitivity_signal
  id: variable
  parameters:
    value: '1.5756'
  states: {}
- name: signal_bandwidth
  id: variable
  parameters:
    value: '540202'
  states: {}
- name: signal_bandwidth_1
  id: variable
  parameters:
    value: '940466'
  states: {}
- name: signal_bandwidth_2
  id: variable
  parameters:
    value: '860402'
  states: {}
- name: signal_bandwidth_3
  id: variable
  parameters:
    value: '250116'
  states: {}
- name: taps_lpf
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate, 19230, 2000)
  states: {}
- name: taps_lpf_pre
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate, 270000, 10000)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\wangt\Desktop\rec\sig1
    repeat: 'True'
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '20'
    bandwidth: signal_bandwidth_1
    buffer_size: '3276800'
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: fc
    samplerate: samp_rate
    type: fc32
    uri: pluto.local
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', iio_pluto_sink_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
