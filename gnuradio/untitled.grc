options:
  parameters:
    author: wangt
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: '0.0625'
    mu: '0.5'
    omega: '52'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_gfsk_mod_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '52'
    sensitivity: sensitivity_inf_1
  states: {}
- name: digital_gfsk_mod_0_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '52'
    sensitivity: sensitivity_inf_1
  states: {}
- name: digital_gfsk_mod_0_0_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '52'
    sensitivity: sensitivity_inf_1
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '52'
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: iio_pluto_sink_0_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '60'
    bandwidth: signal_bandwidth
    buffer_size: '32768'
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: fc_blue_1
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.3
  states: {}
- name: iio_pluto_sink_0_0_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '60'
    bandwidth: signal_bandwidth
    buffer_size: '32768'
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: fc_blue_1
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.3
  states: {}
- name: iio_pluto_sink_0_0_0_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: signal_bandwidth
    buffer_size: '32768'
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: fc_blue_1
    samplerate: samp_rate
    type: fc32
    uri: pluto.local
  states: {}

connections:
- [blocks_pack_k_bits_bb_0_0_0, '0', digital_gfsk_mod_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_0, '0', digital_gfsk_mod_0_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_0_0, '0', digital_gfsk_mod_0_0_0_0, '0']
- [digital_gfsk_mod_0_0, '0', iio_pluto_sink_0_0_0, '0']
- [digital_gfsk_mod_0_0_0, '0', iio_pluto_sink_0_0_0_0, '0']
- [digital_gfsk_mod_0_0_0_0, '0', iio_pluto_sink_0_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
